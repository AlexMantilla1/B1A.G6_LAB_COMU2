<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N2</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>64000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Spb</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>Rb*Spb</value></param>
</block>
<block>
<key>E3TRadio_Zero_Order_Hold</key>
<param><key>id</key><value>E3TRadio_Zero_Order_Hold_0</value></param>
<param><key>k</key><value>Spb</value></param>
</block>
<block>
<key>E3TRadio_fft_jesus</key>
<param><key>id</key><value>E3TRadio_fft_jesus_0</value></param>
<param><key>N</key><value>N2</value></param>
<param><key>W</key><value>exponencial</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>E3TRadio_fft_jesus</key>
<param><key>id</key><value>E3TRadio_fft_jesus_0_0</value></param>
<param><key>N</key><value>N2</value></param>
<param><key>W</key><value>triangular</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>E3TRadio_fft_jesus</key>
<param><key>id</key><value>E3TRadio_fft_jesus_0_0_0</value></param>
<param><key>N</key><value>N2</value></param>
<param><key>W</key><value>binomial</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>E3TRadio_fft_jesus</key>
<param><key>id</key><value>E3TRadio_fft_jesus_0_0_0_0</value></param>
<param><key>N</key><value>N2</value></param>
<param><key>W</key><value>potencia</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>E3TRadio_unipolar_to_bipolar_ff</key>
<param><key>id</key><value>E3TRadio_unipolar_to_bipolar_ff_0</value></param>
<param><key>Amp</key><value>1.0</value></param>
</block>
<block>
<key>E3TRadio_vector_average_hob</key>
<param><key>id</key><value>E3TRadio_vector_average_hob_0</value></param>
<param><key>Nensayos</key><value>1000000000</value></param>
<param><key>N</key><value>N2</value></param>
</block>
<block>
<key>E3TRadio_vector_average_hob</key>
<param><key>id</key><value>E3TRadio_vector_average_hob_0_0</value></param>
<param><key>Nensayos</key><value>1000000000</value></param>
<param><key>N</key><value>N2</value></param>
</block>
<block>
<key>E3TRadio_vector_average_hob</key>
<param><key>id</key><value>E3TRadio_vector_average_hob_0_0_0</value></param>
<param><key>Nensayos</key><value>1000000000</value></param>
<param><key>N</key><value>N2</value></param>
</block>
<block>
<key>E3TRadio_vector_average_hob</key>
<param><key>id</key><value>E3TRadio_vector_average_hob_0_0_0_0</value></param>
<param><key>Nensayos</key><value>1000000000</value></param>
<param><key>N</key><value>N2</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>N2</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
<param><key>vlen</key><value>N2</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0</value></param>
<param><key>vlen</key><value>N2</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0</value></param>
<param><key>vlen</key><value>N2</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>label1</key><value>Exponencial</value></param>
<param><key>label2</key><value>Triangular</value></param>
<param><key>label3</key><value>Binomial</value></param>
<param><key>label4</key><value>Potencial</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N2</value></param>
<param><key>x_axis_label</key><value>"Frecuency"</value></param>
<param><key>x_start</key><value>-samp_rate/2</value></param>
<param><key>x_step</key><value>samp_rate/2</value></param>
<param><key>x_units</key><value>"Hz"</value></param>
<param><key>ymax</key><value>N2*15</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>y_axis_label</key><value>"Amplitud"</value></param>
<param><key>y_units</key><value>"Watt/Hz"</value></param>
</block>
<connection><source_block_id>E3TRadio_Zero_Order_Hold_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_fft_jesus_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_fft_jesus_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_fft_jesus_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_fft_jesus_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_unipolar_to_bipolar_ff_0</source_block_id><sink_block_id>E3TRadio_Zero_Order_Hold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_vector_average_hob_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_vector_average_hob_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>E3TRadio_vector_average_hob_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>E3TRadio_vector_average_hob_0_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>E3TRadio_vector_average_hob_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>E3TRadio_vector_average_hob_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0</source_block_id><sink_block_id>E3TRadio_vector_average_hob_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0</source_block_id><sink_block_id>E3TRadio_vector_average_hob_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>E3TRadio_unipolar_to_bipolar_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>E3TRadio_fft_jesus_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>E3TRadio_fft_jesus_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>E3TRadio_fft_jesus_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>E3TRadio_fft_jesus_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
